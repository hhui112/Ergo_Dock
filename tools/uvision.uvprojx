# Keil uVision project uvision.uvprojx, settings and files
target  (ARM-ADS)
  device: LPC1768 NXP
  pack: Linkedsemi.xxxx.1.0.0
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
